options:
  parameters:
    author: Alén Space
    generate_options: no_gui
    id: fft_average
    output_language: python
    run_options: run
    title: FFT Average
  states: {}

blocks:
- name: fft_power_offset
  id: variable
  parameters:
    value: '-10*math.log10(fft_size) - 10*math.log10(float(fft_window_power))'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_window
  id: variable
  parameters:
    value: window.blackmanharris(fft_size)
  states: {}
- name: fft_window_power
  id: variable
  parameters:
    value: sum([x*x for x in fft_window])
  states: {}
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: hostname
  id: variable
  parameters:
    value: '"10.42.0.100"'
  states: {state: disabled}
- name: hostname
  id: variable
  parameters:
    comment: Use this hostname when running in TOTEM
    value: None
  states: {}
- name: num_ffts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: soapy_dev
  id: variable
  parameters:
    value: '"driver=totem" + (f",hostname={hostname}" if hostname else "")'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fft_output.bin
    type: float
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_ffts
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: fft_power_offset
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: fft_window
  states: {}
- name: math0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'True'
    ant0: B_BALANCED
    balance0: '0'
    bw0: samp_rate
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    dev: soapy_dev
    devname: custom
    gain_mode0: Specific
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_head_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
