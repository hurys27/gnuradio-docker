options:
  parameters:
    author: Alén Space
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Waterfall
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: hostname
  id: variable
  parameters:
    value: '"10.42.0.100"'
  states: {}
- name: hostname_0
  id: variable
  parameters:
    comment: Use this hostname when running in TOTEM
    value: None
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: soapy_dev
  id: variable
  parameters:
    value: '"driver=totem" + (f",hostname={hostname}" if hostname else "")'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'True'
    ant0: B_BALANCED
    balance0: '0'
    bw0: samp_rate
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    dev: soapy_dev
    devname: custom
    gain_mode0: Specific
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
